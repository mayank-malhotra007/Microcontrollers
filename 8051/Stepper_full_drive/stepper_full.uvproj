# Keil uVision project stepper_full.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C51 Atmel
  cpu: IRAM(0-0x7F) IROM(0-0xFFF) CLOCK(24000000)
  output: stepper_full +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: stepper_full.c
